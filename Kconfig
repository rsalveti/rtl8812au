## Kconfig
```kconfig
config RTL8812AU
	tristate "Realtek 8812A USB WiFi"
	depends on USB && CFG80211
	---help---
	  Help message of RTL8812AU
```
